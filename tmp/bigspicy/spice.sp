** SPICE netlist generated by bigspicy.py at Fri Dec  9 11:22:53 2022 UTC
.SUBCKT iiitb_4bbc
+ UpOrDown clkin reset Count.0 Count.1 Count.2 Count.3
** replacing _20_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__20__0 VGND net3 _20__a_75_212# no_conn_0 sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__20__1 _08_ _20__a_75_212# VPWR no_conn_1 sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__20__2 _08_ _20__a_75_212# VGND no_conn_0 sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__20__3 VPWR net3 _20__a_75_212# no_conn_1 sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _22_ with the contents of sky130_fd_sc_hd__nand2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__22__0 _09_ _08_ VPWR no_conn_3 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__22__1 VPWR net4 _09_ no_conn_3 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_113_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__22__2 VGND net4 _22__a_113_47# no_conn_2 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_113_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__22__3 _22__a_113_47# _08_ _09_ no_conn_2 sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _23_ with the contents of sky130_fd_sc_hd__or2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_150_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__23__0 _23__a_150_297# _08_ VPWR no_conn_5 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_68_297# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__23__1 VGND _23__a_68_297# _10_ no_conn_4 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_68_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__23__2 VGND net4 _23__a_68_297# no_conn_4 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_68_297# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__23__3 _23__a_68_297# _08_ VGND no_conn_4 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_68_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_150_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__23__4 _23__a_68_297# net4 _23__a_150_297# no_conn_5 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_68_297# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__23__5 VPWR _23__a_68_297# _10_ no_conn_5 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _24_ with the contents of sky130_fd_sc_hd__a21oi_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_199_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__24__0 _24__a_199_47# _10_ VGND no_conn_6 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_113_297# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__24__1 _24__a_113_297# _09_ VPWR no_conn_7 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_113_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__24__2 _11_ net1 _24__a_113_297# no_conn_7 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__24__3 VGND net1 _11_ no_conn_6 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: a_113_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__24__4 VPWR _10_ _24__a_113_297# no_conn_7 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_199_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__24__5 _11_ _09_ _24__a_199_47# no_conn_6 sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _25_ with the contents of sky130_fd_sc_hd__and3_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_181_47# w=1]]', 'g: [connection X0/g =>[signal: C w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__25__0 _25__a_181_47# _10_ VGND no_conn_8 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__25__1 _25__a_27_47# net1 VPWR no_conn_9 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_47# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__25__2 VPWR _09_ _25__a_27_47# no_conn_9 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__25__3 VPWR _25__a_27_47# _12_ no_conn_9 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_47# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_181_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__25__4 _25__a_109_47# _09_ _25__a_181_47# no_conn_8 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: a_109_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__25__5 _25__a_27_47# net1 _25__a_109_47# no_conn_8 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_27_47# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__25__6 VGND _25__a_27_47# _12_ no_conn_8 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_47# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__25__7 _25__a_27_47# _10_ VPWR no_conn_9 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u

** replacing _26_ with the contents of sky130_fd_sc_hd__or2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_150_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__26__0 _26__a_150_297# _11_ VPWR no_conn_11 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_68_297# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__26__1 VGND _26__a_68_297# _13_ no_conn_10 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_68_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__26__2 VGND _12_ _26__a_68_297# no_conn_10 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_68_297# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__26__3 _26__a_68_297# _11_ VGND no_conn_10 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_68_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_150_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__26__4 _26__a_68_297# _12_ _26__a_150_297# no_conn_11 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_68_297# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__26__5 VPWR _26__a_68_297# _13_ no_conn_11 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _27_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__27__0 VGND _13_ _27__a_75_212# no_conn_12 sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__27__1 _01_ _27__a_75_212# VPWR no_conn_13 sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__27__2 _01_ _27__a_75_212# VGND no_conn_12 sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__27__3 VPWR _13_ _27__a_75_212# no_conn_13 sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _28_ with the contents of sky130_fd_sc_hd__nand3_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: Y w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__28__0 VPWR _08_ _14_ no_conn_15 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_109_47# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_193_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__28__1 _28__a_109_47# net4 _28__a_193_47# no_conn_14 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: C w=1]]', 's: [connection X2/s =>[signal: a_109_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__28__2 VGND net5 _28__a_109_47# no_conn_14 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_193_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__28__3 _28__a_193_47# _08_ _14_ no_conn_14 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: Y w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__28__4 VPWR net5 _14_ no_conn_15 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__28__5 _14_ net4 VPWR no_conn_15 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _29_ with the contents of sky130_fd_sc_hd__a21o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__29__0 _29__a_384_47# net4 VGND no_conn_16 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_81_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__29__1 _15_ _29__a_81_21# VPWR no_conn_17 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_81_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_299_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__29__2 _29__a_81_21# net5 _29__a_299_297# no_conn_17 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_81_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__29__3 VGND net5 _29__a_81_21# no_conn_16 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_299_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__29__4 _29__a_299_297# _08_ VPWR no_conn_17 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_299_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__29__5 VPWR net4 _29__a_299_297# no_conn_17 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_81_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__29__6 _15_ _29__a_81_21# VGND no_conn_16 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_81_21# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_384_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__29__7 _29__a_81_21# _08_ _29__a_384_47# no_conn_16 sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _30_ with the contents of sky130_fd_sc_hd__nand2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__30__0 _16_ _14_ VPWR no_conn_19 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__30__1 VPWR _15_ _16_ no_conn_19 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_113_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__30__2 VGND _15_ _30__a_113_47# no_conn_18 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_113_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__30__3 _30__a_113_47# _14_ _16_ no_conn_18 sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _31_ with the contents of sky130_fd_sc_hd__xnor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_377_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__31__0 VPWR _11_ _31__a_377_297# no_conn_21 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_377_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__31__1 _31__a_377_297# _16_ _02_ no_conn_21 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: a_47_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__31__2 _02_ _31__a_47_47# VPWR no_conn_21 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_129_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__31__3 _31__a_129_47# _11_ VGND no_conn_20 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_285_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__31__4 VGND _16_ _31__a_285_47# no_conn_20 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_47_47# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_129_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__31__5 _31__a_47_47# _16_ _31__a_129_47# no_conn_20 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_47_47# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__31__6 VPWR _16_ _31__a_47_47# no_conn_21 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_47_47# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__31__7 _31__a_47_47# _11_ VPWR no_conn_21 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: a_285_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__31__8 VGND _11_ _31__a_285_47# no_conn_20 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_285_47# w=1]]', 'g: [connection X9/g =>[signal: a_47_47# w=1]]', 's: [connection X9/s =>[signal: Y w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__31__9 _31__a_285_47# _31__a_47_47# _02_ no_conn_20 sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _32_ with the contents of sky130_fd_sc_hd__or3_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_29_53# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__32__0 VPWR _32__a_29_53# _17_ no_conn_23 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_111_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_183_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__32__1 _32__a_111_297# net4 _32__a_183_297# no_conn_23 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_29_53# w=1]]', 'g: [connection X2/g =>[signal: C w=1]]', 's: [connection X2/s =>[signal: a_111_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__32__2 _32__a_29_53# net5 _32__a_111_297# no_conn_23 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_29_53# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__32__3 VGND _32__a_29_53# _17_ no_conn_22 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_29_53# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__32__4 _32__a_29_53# net5 VGND no_conn_22 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_29_53# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__32__5 _32__a_29_53# _08_ VGND no_conn_22 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_183_297# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__32__6 _32__a_183_297# _08_ VPWR no_conn_23 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: a_29_53# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__32__7 VGND net4 _32__a_29_53# no_conn_22 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _33_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__33__0 VPWR net1 _33__a_218_374# no_conn_25 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__33__1 _33__a_76_199# _17_ _33__a_439_47# no_conn_24 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__33__2 _33__a_535_374# _33__a_505_21# VPWR no_conn_25 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__33__3 VPWR net1 _33__a_505_21# no_conn_25 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__33__4 _33__a_76_199# _14_ _33__a_535_374# no_conn_25 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__33__5 _33__a_218_47# _14_ _33__a_76_199# no_conn_24 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__33__6 _33__a_218_374# _17_ _33__a_76_199# no_conn_25 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__33__7 _18_ _33__a_76_199# VGND no_conn_24 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__33__8 _18_ _33__a_76_199# VPWR no_conn_25 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__33__9 VGND net1 _33__a_218_47# no_conn_24 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__33__10 VGND net1 _33__a_505_21# no_conn_24 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__33__11 _33__a_439_47# _33__a_505_21# VGND no_conn_24 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _34_ with the contents of sky130_fd_sc_hd__xnor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_377_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__34__0 VPWR net6 _34__a_377_297# no_conn_27 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_377_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__34__1 _34__a_377_297# _18_ _03_ no_conn_27 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: a_47_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__34__2 _03_ _34__a_47_47# VPWR no_conn_27 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_129_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__34__3 _34__a_129_47# net6 VGND no_conn_26 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_285_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__34__4 VGND _18_ _34__a_285_47# no_conn_26 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_47_47# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_129_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__34__5 _34__a_47_47# _18_ _34__a_129_47# no_conn_26 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_47_47# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__34__6 VPWR _18_ _34__a_47_47# no_conn_27 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_47_47# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__34__7 _34__a_47_47# net6 VPWR no_conn_27 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: a_285_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__34__8 VGND net6 _34__a_285_47# no_conn_26 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_285_47# w=1]]', 'g: [connection X9/g =>[signal: a_47_47# w=1]]', 's: [connection X9/s =>[signal: Y w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__34__9 _34__a_285_47# _34__a_47_47# _03_ no_conn_26 sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _35_ with the contents of sky130_fd_sc_hd__buf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__35__0 VGND _35__a_27_47# _19_ no_conn_28 sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__35__1 _35__a_27_47# net2 VPWR no_conn_29 sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_27_47# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__35__2 _35__a_27_47# net2 VGND no_conn_28 sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__35__3 VPWR _35__a_27_47# _19_ no_conn_29 sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _40_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__40__0 _40__a_1270_413# _40__a_1283_21# VPWR no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__40__1 VPWR _40__a_543_47# _40__a_761_289# no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__40__2 VGND _40__a_543_47# _40__a_761_289# no_conn_30 sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__40__3 VGND _00_ _40__a_448_47# no_conn_30 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__40__4 _40__a_1108_47# _40__a_193_47# _40__a_1270_413# no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__40__5 VGND _40__a_1283_21# net3 no_conn_30 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__40__6 _40__a_1217_47# _40__a_1283_21# VGND no_conn_30 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__40__7 _40__a_448_47# _40__a_27_47# _40__a_543_47# no_conn_30 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__40__8 _40__a_448_47# _40__a_193_47# _40__a_543_47# no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__40__9 _40__a_543_47# _40__a_193_47# _40__a_639_47# no_conn_30 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__40__10 _40__a_1108_47# _40__a_27_47# _40__a_1217_47# no_conn_30 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__40__11 _40__a_1462_47# _40__a_1108_47# _40__a_1283_21# no_conn_30 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__40__12 _40__a_543_47# _40__a_27_47# _40__a_651_413# no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__40__13 _40__a_805_47# _04_ VGND no_conn_30 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__40__14 _40__a_761_289# _40__a_193_47# _40__a_1108_47# no_conn_30 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__40__15 VPWR _04_ _40__a_651_413# no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__40__16 VGND _40__a_27_47# _40__a_193_47# no_conn_30 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__40__17 _40__a_27_47# clknet_1_0__leaf_clkin VGND no_conn_30 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__40__18 _40__a_27_47# clknet_1_0__leaf_clkin VPWR no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__40__19 VPWR _40__a_1283_21# net3 no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__40__20 VPWR _40__a_27_47# _40__a_193_47# no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__40__21 _40__a_1283_21# _40__a_1108_47# VPWR no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__40__22 VGND _04_ _40__a_1462_47# no_conn_30 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__40__23 VPWR _00_ _40__a_448_47# no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__40__24 _40__a_651_413# _40__a_761_289# VPWR no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__40__25 _40__a_761_289# _40__a_27_47# _40__a_1108_47# no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__40__26 VPWR _04_ _40__a_1283_21# no_conn_31 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__40__27 _40__a_639_47# _40__a_761_289# _40__a_805_47# no_conn_30 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _41_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__41__0 _41__a_1270_413# _41__a_1283_21# VPWR no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__41__1 VPWR _41__a_543_47# _41__a_761_289# no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__41__2 VGND _41__a_543_47# _41__a_761_289# no_conn_32 sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__41__3 VGND _01_ _41__a_448_47# no_conn_32 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__41__4 _41__a_1108_47# _41__a_193_47# _41__a_1270_413# no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__41__5 VGND _41__a_1283_21# net4 no_conn_32 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__41__6 _41__a_1217_47# _41__a_1283_21# VGND no_conn_32 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__41__7 _41__a_448_47# _41__a_27_47# _41__a_543_47# no_conn_32 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__41__8 _41__a_448_47# _41__a_193_47# _41__a_543_47# no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__41__9 _41__a_543_47# _41__a_193_47# _41__a_639_47# no_conn_32 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__41__10 _41__a_1108_47# _41__a_27_47# _41__a_1217_47# no_conn_32 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__41__11 _41__a_1462_47# _41__a_1108_47# _41__a_1283_21# no_conn_32 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__41__12 _41__a_543_47# _41__a_27_47# _41__a_651_413# no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__41__13 _41__a_805_47# _05_ VGND no_conn_32 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__41__14 _41__a_761_289# _41__a_193_47# _41__a_1108_47# no_conn_32 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__41__15 VPWR _05_ _41__a_651_413# no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__41__16 VGND _41__a_27_47# _41__a_193_47# no_conn_32 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__41__17 _41__a_27_47# clknet_1_0__leaf_clkin VGND no_conn_32 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__41__18 _41__a_27_47# clknet_1_0__leaf_clkin VPWR no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__41__19 VPWR _41__a_1283_21# net4 no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__41__20 VPWR _41__a_27_47# _41__a_193_47# no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__41__21 _41__a_1283_21# _41__a_1108_47# VPWR no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__41__22 VGND _05_ _41__a_1462_47# no_conn_32 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__41__23 VPWR _01_ _41__a_448_47# no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__41__24 _41__a_651_413# _41__a_761_289# VPWR no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__41__25 _41__a_761_289# _41__a_27_47# _41__a_1108_47# no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__41__26 VPWR _05_ _41__a_1283_21# no_conn_33 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__41__27 _41__a_639_47# _41__a_761_289# _41__a_805_47# no_conn_32 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _42_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__42__0 _42__a_1270_413# _42__a_1283_21# VPWR no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__42__1 VPWR _42__a_543_47# _42__a_761_289# no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__42__2 VGND _42__a_543_47# _42__a_761_289# no_conn_34 sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__42__3 VGND _02_ _42__a_448_47# no_conn_34 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__42__4 _42__a_1108_47# _42__a_193_47# _42__a_1270_413# no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__42__5 VGND _42__a_1283_21# net5 no_conn_34 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__42__6 _42__a_1217_47# _42__a_1283_21# VGND no_conn_34 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__42__7 _42__a_448_47# _42__a_27_47# _42__a_543_47# no_conn_34 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__42__8 _42__a_448_47# _42__a_193_47# _42__a_543_47# no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__42__9 _42__a_543_47# _42__a_193_47# _42__a_639_47# no_conn_34 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__42__10 _42__a_1108_47# _42__a_27_47# _42__a_1217_47# no_conn_34 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__42__11 _42__a_1462_47# _42__a_1108_47# _42__a_1283_21# no_conn_34 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__42__12 _42__a_543_47# _42__a_27_47# _42__a_651_413# no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__42__13 _42__a_805_47# _06_ VGND no_conn_34 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__42__14 _42__a_761_289# _42__a_193_47# _42__a_1108_47# no_conn_34 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__42__15 VPWR _06_ _42__a_651_413# no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__42__16 VGND _42__a_27_47# _42__a_193_47# no_conn_34 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__42__17 _42__a_27_47# clknet_1_1__leaf_clkin VGND no_conn_34 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__42__18 _42__a_27_47# clknet_1_1__leaf_clkin VPWR no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__42__19 VPWR _42__a_1283_21# net5 no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__42__20 VPWR _42__a_27_47# _42__a_193_47# no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__42__21 _42__a_1283_21# _42__a_1108_47# VPWR no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__42__22 VGND _06_ _42__a_1462_47# no_conn_34 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__42__23 VPWR _02_ _42__a_448_47# no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__42__24 _42__a_651_413# _42__a_761_289# VPWR no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__42__25 _42__a_761_289# _42__a_27_47# _42__a_1108_47# no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__42__26 VPWR _06_ _42__a_1283_21# no_conn_35 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__42__27 _42__a_639_47# _42__a_761_289# _42__a_805_47# no_conn_34 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _43_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__43__0 _43__a_1270_413# _43__a_1283_21# VPWR no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__43__1 VPWR _43__a_543_47# _43__a_761_289# no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__43__2 VGND _43__a_543_47# _43__a_761_289# no_conn_36 sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__43__3 VGND _03_ _43__a_448_47# no_conn_36 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__43__4 _43__a_1108_47# _43__a_193_47# _43__a_1270_413# no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__43__5 VGND _43__a_1283_21# net6 no_conn_36 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__43__6 _43__a_1217_47# _43__a_1283_21# VGND no_conn_36 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__43__7 _43__a_448_47# _43__a_27_47# _43__a_543_47# no_conn_36 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__43__8 _43__a_448_47# _43__a_193_47# _43__a_543_47# no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__43__9 _43__a_543_47# _43__a_193_47# _43__a_639_47# no_conn_36 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__43__10 _43__a_1108_47# _43__a_27_47# _43__a_1217_47# no_conn_36 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__43__11 _43__a_1462_47# _43__a_1108_47# _43__a_1283_21# no_conn_36 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__43__12 _43__a_543_47# _43__a_27_47# _43__a_651_413# no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__43__13 _43__a_805_47# _07_ VGND no_conn_36 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__43__14 _43__a_761_289# _43__a_193_47# _43__a_1108_47# no_conn_36 sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__43__15 VPWR _07_ _43__a_651_413# no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__43__16 VGND _43__a_27_47# _43__a_193_47# no_conn_36 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__43__17 _43__a_27_47# clknet_1_1__leaf_clkin VGND no_conn_36 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__43__18 _43__a_27_47# clknet_1_1__leaf_clkin VPWR no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__43__19 VPWR _43__a_1283_21# net6 no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__43__20 VPWR _43__a_27_47# _43__a_193_47# no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__43__21 _43__a_1283_21# _43__a_1108_47# VPWR no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__43__22 VGND _07_ _43__a_1462_47# no_conn_36 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__43__23 VPWR _03_ _43__a_448_47# no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__43__24 _43__a_651_413# _43__a_761_289# VPWR no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__43__25 _43__a_761_289# _43__a_27_47# _43__a_1108_47# no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__43__26 VPWR _07_ _43__a_1283_21# no_conn_37 sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__43__27 _43__a_639_47# _43__a_761_289# _43__a_805_47# no_conn_36 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing input1 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input1_0 VGND UpOrDown input1_a_75_212# no_conn_38 sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input1_1 net1 input1_a_75_212# VPWR no_conn_39 sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input1_2 net1 input1_a_75_212# VGND no_conn_38 sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input1_3 VPWR UpOrDown input1_a_75_212# no_conn_39 sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input2 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input2_0 VGND reset input2_a_75_212# no_conn_40 sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input2_1 net2 input2_a_75_212# VPWR no_conn_41 sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input2_2 net2 input2_a_75_212# VGND no_conn_40 sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input2_3 VPWR reset input2_a_75_212# no_conn_41 sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing output3 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output3_0 Count.0 output3_a_27_47# VGND no_conn_42 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output3_1 output3_a_27_47# net3 VPWR no_conn_43 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output3_2 VGND output3_a_27_47# Count.0 no_conn_42 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output3_3 Count.0 output3_a_27_47# VPWR no_conn_43 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output3_4 VPWR output3_a_27_47# Count.0 no_conn_43 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output3_5 output3_a_27_47# net3 VGND no_conn_42 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output4 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output4_0 Count.1 output4_a_27_47# VGND no_conn_44 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output4_1 output4_a_27_47# net4 VPWR no_conn_45 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output4_2 VGND output4_a_27_47# Count.1 no_conn_44 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output4_3 Count.1 output4_a_27_47# VPWR no_conn_45 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output4_4 VPWR output4_a_27_47# Count.1 no_conn_45 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output4_5 output4_a_27_47# net4 VGND no_conn_44 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output5 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output5_0 Count.2 output5_a_27_47# VGND no_conn_46 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output5_1 output5_a_27_47# net5 VPWR no_conn_47 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output5_2 VGND output5_a_27_47# Count.2 no_conn_46 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output5_3 Count.2 output5_a_27_47# VPWR no_conn_47 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output5_4 VPWR output5_a_27_47# Count.2 no_conn_47 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output5_5 output5_a_27_47# net5 VGND no_conn_46 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing output6 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output6_0 Count.3 output6_a_27_47# VGND no_conn_48 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output6_1 output6_a_27_47# net6 VPWR no_conn_49 sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output6_2 VGND output6_a_27_47# Count.3 no_conn_48 sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output6_3 Count.3 output6_a_27_47# VPWR no_conn_49 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output6_4 VPWR output6_a_27_47# Count.3 no_conn_49 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output6_5 output6_a_27_47# net6 VGND no_conn_48 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_0_clkin with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_0 VPWR clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_1 clknet_0_clkin clkbuf_0_clkin_a_110_47# VGND no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_2 clknet_0_clkin clkbuf_0_clkin_a_110_47# VGND no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_3 clkbuf_0_clkin_a_110_47# clkin VPWR no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_4 VPWR clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_5 clknet_0_clkin clkbuf_0_clkin_a_110_47# VPWR no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_6 clkbuf_0_clkin_a_110_47# clkin VGND no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_7 VPWR clkin clkbuf_0_clkin_a_110_47# no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_8 VGND clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_9 VGND clkin clkbuf_0_clkin_a_110_47# no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_10 clknet_0_clkin clkbuf_0_clkin_a_110_47# VGND no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_11 clknet_0_clkin clkbuf_0_clkin_a_110_47# VGND no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_12 clkbuf_0_clkin_a_110_47# clkin VPWR no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_13 VPWR clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_14 clknet_0_clkin clkbuf_0_clkin_a_110_47# VGND no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_15 VPWR clkin clkbuf_0_clkin_a_110_47# no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_16 VGND clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_17 clknet_0_clkin clkbuf_0_clkin_a_110_47# VGND no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_18 VGND clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_19 VGND clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_20 clknet_0_clkin clkbuf_0_clkin_a_110_47# VPWR no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_21 clknet_0_clkin clkbuf_0_clkin_a_110_47# VPWR no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_22 clknet_0_clkin clkbuf_0_clkin_a_110_47# VPWR no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_23 VPWR clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_24 VPWR clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_25 VGND clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_26 clknet_0_clkin clkbuf_0_clkin_a_110_47# VPWR no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_27 clknet_0_clkin clkbuf_0_clkin_a_110_47# VGND no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_28 VPWR clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_29 VGND clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_30 clknet_0_clkin clkbuf_0_clkin_a_110_47# VGND no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_31 clknet_0_clkin clkbuf_0_clkin_a_110_47# VPWR no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_32 clknet_0_clkin clkbuf_0_clkin_a_110_47# VPWR no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_33 clknet_0_clkin clkbuf_0_clkin_a_110_47# VPWR no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_34 clkbuf_0_clkin_a_110_47# clkin VGND no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_35 VPWR clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_36 VGND clkin clkbuf_0_clkin_a_110_47# no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clkin_37 VPWR clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_51 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_38 VGND clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clkin_39 VGND clkbuf_0_clkin_a_110_47# clknet_0_clkin no_conn_50 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_1_0__f_clkin with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_0 VPWR clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_1 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VGND no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_2 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VGND no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_3 clkbuf_1_0__f_clkin_a_110_47# clknet_0_clkin VPWR no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_4 VPWR clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_5 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VPWR no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_6 clkbuf_1_0__f_clkin_a_110_47# clknet_0_clkin VGND no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_7 VPWR clknet_0_clkin clkbuf_1_0__f_clkin_a_110_47# no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_8 VGND clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_9 VGND clknet_0_clkin clkbuf_1_0__f_clkin_a_110_47# no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_10 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VGND no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_11 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VGND no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_12 clkbuf_1_0__f_clkin_a_110_47# clknet_0_clkin VPWR no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_13 VPWR clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_14 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VGND no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_15 VPWR clknet_0_clkin clkbuf_1_0__f_clkin_a_110_47# no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_16 VGND clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_17 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VGND no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_18 VGND clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_19 VGND clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_20 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VPWR no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_21 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VPWR no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_22 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VPWR no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_23 VPWR clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_24 VPWR clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_25 VGND clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_26 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VPWR no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_27 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VGND no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_28 VPWR clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_29 VGND clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_30 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VGND no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_31 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VPWR no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_32 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VPWR no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_33 clknet_1_0__leaf_clkin clkbuf_1_0__f_clkin_a_110_47# VPWR no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_34 clkbuf_1_0__f_clkin_a_110_47# clknet_0_clkin VGND no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_35 VPWR clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_36 VGND clknet_0_clkin clkbuf_1_0__f_clkin_a_110_47# no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_1_0__f_clkin_37 VPWR clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_53 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_38 VGND clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_1_0__f_clkin_39 VGND clkbuf_1_0__f_clkin_a_110_47# clknet_1_0__leaf_clkin no_conn_52 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_1_1__f_clkin with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_0 VPWR clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_1 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VGND no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_2 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VGND no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_3 clkbuf_1_1__f_clkin_a_110_47# clknet_0_clkin VPWR no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_4 VPWR clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_5 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VPWR no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_6 clkbuf_1_1__f_clkin_a_110_47# clknet_0_clkin VGND no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_7 VPWR clknet_0_clkin clkbuf_1_1__f_clkin_a_110_47# no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_8 VGND clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_9 VGND clknet_0_clkin clkbuf_1_1__f_clkin_a_110_47# no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_10 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VGND no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_11 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VGND no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_12 clkbuf_1_1__f_clkin_a_110_47# clknet_0_clkin VPWR no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_13 VPWR clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_14 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VGND no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_15 VPWR clknet_0_clkin clkbuf_1_1__f_clkin_a_110_47# no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_16 VGND clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_17 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VGND no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_18 VGND clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_19 VGND clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_20 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VPWR no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_21 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VPWR no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_22 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VPWR no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_23 VPWR clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_24 VPWR clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_25 VGND clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_26 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VPWR no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_27 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VGND no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_28 VPWR clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_29 VGND clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_30 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VGND no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_31 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VPWR no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_32 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VPWR no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_33 clknet_1_1__leaf_clkin clkbuf_1_1__f_clkin_a_110_47# VPWR no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_34 clkbuf_1_1__f_clkin_a_110_47# clknet_0_clkin VGND no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_35 VPWR clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_36 VGND clknet_0_clkin clkbuf_1_1__f_clkin_a_110_47# no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_1_1__f_clkin_37 VPWR clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_55 sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_38 VGND clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_1_1__f_clkin_39 VGND clkbuf_1_1__f_clkin_a_110_47# clknet_1_1__leaf_clkin no_conn_54 sky130_fd_pr__nfet_01v8 W=420000u L=150000u

.ENDS
